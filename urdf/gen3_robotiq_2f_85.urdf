Commit message: updates

File: urdf/gen3_robotiq_2f_85.urdf (robot description, URDF)
Before this commit: robot gen3_robotiq_2f_85, 24 links, 23 joints
Links:
- link bracelet_link: mass 0.925 -> 1.425
